Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-11-18T11:05:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.60.25 - Exporter 21.1.60.25 - IFC Model Exchange with Archicad 24.0.0.4000
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 18 11:05:14 2022 * Host: DESKTOP-IHH7OF8 * Database: C:\Users\BMP_02\AppData\Local\Temp\bd2fa207-007e-471a-b6da-f1724c5363a1\ee4fcf32-4ba1-4287-a202-9d0ea5f5837b\ifc * Database version: 5507 * Database creation date: Fri Nov 18 11:05:14 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Nov 18 11:05:14 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 18 11:05:14 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point

# IfcDistributionPort (8)
Description: Flow
Name | FlowDirection
2 x Port_557177 | SOURCEANDSINK
2 x Port_557177 | SOURCE
4 x Port_557177 | SINK

# IfcEnergyConversionDevice: RSen_57_ME_FB_air handling unit - modular - t_daikin:atb03rasnadbt00 - air handling unit - right_daikin_lxwxh 1580x550x1550 mm, RSen_57_ME_FB_air handling unit - modular - t_daikin:atb03rasnadbt00 - air handling unit - right_daikin_lxwxh 1580x550x1550 mm:557177
In: Level 1
Type - PredefinedType: AIRHANDLER; Classification: 57.10.10.10 (Uniformat); Material: RSen_x_rgb 255 128 128 T80 red_gen (4), RSen_x_rgb 255 255 255 T00 pure white_gen (4)
Type - Constraints - Default Elevation: 0 mm
Type - Construction - TBQen_C_diameter_type: OD; TBQen_C_diameter_type_index: 1; TBQen_C_SOg_ME_01: standard; TBQen_C_SOg_ME_02: standard
Type - Dimensions - RSen_C_height: 1550 mm; RSen_C_length: 1580 mm; RSen_C_width: 550 mm
Type - Electrical - RSen_E_c01_apparent_power: 1060 W; RSen_E_c01_current: 0 A; RSen_E_c01_division_engine: no; RSen_E_c01_load_class: Other; RSen_E_c01_number_of_poles: 1; RSen_E_c01_voltage: 230 V; TBQen_E_c01_power: 1060 W; TBQen_E_c01_power_factor: 1
Type - Identity Data - Assembly Code: 57.10.10.10; Description: Ventilation; Manufacturer: Daikin Europe N.V.; Model: Modular T; OmniClass Number: 23.75.35.14; OmniClass Title: Air Handling Units; RSen_C_code_article: ATB03RASNADBT00; RSen_C_code_ETIM: Ventilation appliance; RSen_C_code_ETIM_URL: https://prod.etim-international.com/Class/Details?classId=EC000267&classVersion=5; RSen_C_code_gtin: -; RSen_C_code_product_class: ATB-S; RSen_C_content_creator: © ThorbiQ; RSen_C_content_date_changed: 14/01/2021; RSen_C_content_date_issue: 14/01/2021; RSen_C_content_provider: Daikin Europe N.V.; RSen_C_content_version: 2.0.0; RSen_C_description: Ventilation; RSen_C_model: Modular T; RSen_C_revit_version: 2018; RSen_C_type: Air handling unit - right; RSen_C_type_comments: Indoor Unit; TBQ_I BaseKeynote: 57.10.10.10; TBQen_C_code_product: ATB03RAS; TBQen_C_IFC_version: 2x3; TBQen_C_license: Creative Commons Attribution NoDerivs (CC-ND); TBQen_C_license_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; Type Comments: Indoor Unit; Type Name: atb03rasnadbt00 - air handling unit - right_daikin_lxwxh 1580x550x1550 mm; URL: www.daikineurope.com
Type - Materials and Finishes - RSen_C_material: RSen_x_rgb 255 255 255 T00 pure white_gen
Type - Mechanical - RSen_P_c01_load_value: 0; RSen_P_c02_load_value: 0; TBQ_I Air flow rate_speed 1: 7.8477 m3/s; TBQ_I Air flow rate_speed 2: 0 m3/s; TBQ_I Air flow rate_speed 3: 0 m3/s
Type - Model Properties - TBQen_C_mounting_ceiling: no; TBQen_C_mounting_floor: yes; TBQen_C_mounting_wall: no
Type - Other - Category: Mechanical Equipment; Family Name: RSen_57_ME_FB_air handling unit - modular - t_daikin; RSen_E_c01_description: c01_el; RSen_E_c02_description: c02_controls; RSen_M_c01_description: c01_fresh air_outdoor; RSen_M_c01_diameter: 250 mm; RSen_M_c01_height: 0 mm; RSen_M_c01_width: 0 mm; RSen_M_c02_description: c02_exhaust air; RSen_M_c02_diameter: 250 mm; RSen_M_c02_height: 0 mm; RSen_M_c02_width: 0 mm; RSen_M_c03_description: c03_supply air; RSen_M_c03_diameter: 250 mm; RSen_M_c03_height: 0 mm; RSen_M_c03_width: 0 mm; RSen_M_c04_description: c04_return air; RSen_M_c04_diameter: 250 mm; RSen_M_c04_height: 0 mm; RSen_M_c04_width: 0 mm; RSen_P_c01_description: c01_drain piping connection; RSen_P_c01_diameter: 21.3 mm; RSen_P_c02_description: c01_drain piping connection; RSen_P_c02_diameter: 21.3 mm; TBQen_E_c01_power_factor_state: Lagging; TBQen_E_c01_system_type: Power - Balanced; TBQen_E_c01_yes_no: yes; TBQen_E_c02_yes_no: yes; TBQen_M_c01_flow_configuration: Preset; TBQen_M_c01_flow_direction: In; TBQen_M_c01_loss_method: Not Defined; TBQen_M_c01_shape: Round; TBQen_M_c01_system_classification: Supply Air; TBQen_M_c01_yes_no: yes; TBQen_M_c02_flow_configuration: Preset; TBQen_M_c02_flow_direction: Out; TBQen_M_c02_loss_method: Not Defined; TBQen_M_c02_shape: Round; TBQen_M_c02_system_classification: Exhaust Air; TBQen_M_c02_yes_no: yes; TBQen_M_c03_flow_configuration: Preset; TBQen_M_c03_flow_direction: Out; TBQen_M_c03_loss_method: Not Defined; TBQen_M_c03_shape: Round; TBQen_M_c03_system_classification: Supply Air; TBQen_M_c03_yes_no: yes; TBQen_M_c04_flow_configuration: Preset; TBQen_M_c04_flow_direction: In; TBQen_M_c04_loss_method: Not Defined; TBQen_M_c04_shape: Round; TBQen_M_c04_system_classification: Return Air; TBQen_M_c04_yes_no: yes; TBQen_P_c01_diameter_calc: 21.3 mm; TBQen_P_c01_flow_configuration: Fixture Units; TBQen_P_c01_flow_direction: Out; TBQen_P_c01_loss_method: Not Defined; TBQen_P_c01_system_classification: Sanitary; TBQen_P_c01_yes_no: yes; TBQen_P_c02_diameter_calc: 21.3 mm; TBQen_P_c02_flow_configuration: Fixture Units; TBQen_P_c02_flow_direction: Out; TBQen_P_c02_loss_method: Not Defined; TBQen_P_c02_system_classification: Sanitary; TBQen_P_c02_yes_no: yes
Type - Pset_DistributionFlowElementCommon - Reference: atb03rasnadbt00 - air handling unit - right_daikin_lxwxh 1580x550x1550 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Daikin Europe N.V.
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Type - Pset_QuantityTakeOff - Reference: atb03rasnadbt00 - air handling unit - right_daikin_lxwxh 1580x550x1550 mm
Material: RSen_x_rgb 255 255 255 T00 pure white_gen, RSen_x_rgb 000 163 228 T00 blue_gen, RSen_x_rgb 079 201 245 T00 blue_gen, RSen_x_rgb 055 053 053 T00 gray_gen, RSen_x_rgb 197 197 197 T00 chrome steel_gen, RSen_x_rgb 000 000 000 T00 black_gen
Pset_DistributionFlowElementCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm; Host: Reference Plane : h_leftright
Construction - TBQen_C_alignment: Center; TBQen_C_alignment_index: 0; TBQen_C_GOg: no; TBQen_C_SOg: yes; TBQen_C_suspension_height: 0 mm
Dimensions - Area: 88.141 m2; Volume: 28.3056 m3
Graphics - TBQen_C_clearance_zone: no; TBQen_C_connection_zone: no; TBQen_C_logo: no; TBQen_C_maintenance_zone: no; TBQen_C_neighbour_unit: no; TBQen_C_neighbour_unit_displacement_back: 0 mm; TBQen_C_neighbour_unit_displacement_front: 0 mm; TBQen_C_neighbour_unit_displacement_left: 0 mm; TBQen_C_neighbour_unit_displacement_right: 0 mm
Identity Data - Mark: 61
Mechanical - RSen_M_c01_flow_rate: 7.8477 m3/s; RSen_M_c02_flow_rate: 7.8477 m3/s; RSen_M_c03_flow_rate: 7.8477 m3/s; RSen_M_c04_flow_rate: 7.8477 m3/s; System Classification: Sanitary,Return Air,Supply Air,Exhaust Air,Power,Controls
Mechanical - Flow - TBQen_M_flow_rate: 7.8477 m3/s; TBQen_M_flow_rate_index: 0; TBQen_M_flow_rate_info: Low
Other - Family: RSen_57_ME_FB_air handling unit - modular - t_daikin: atb03rasnadbt00 - air handling unit - right_daikin_lxwxh 1580x550x1550 mm; Family and Type: RSen_57_ME_FB_air handling unit - modular - t_daikin: atb03rasnadbt00 - air handling unit - right_daikin_lxwxh 1580x550x1550 mm; Type: RSen_57_ME_FB_air handling unit - modular - t_daikin: atb03rasnadbt00 - air handling unit - right_daikin_lxwxh 1580x550x1550 mm; Type Id: RSen_57_ME_FB_air handling unit - modular - t_daikin: atb03rasnadbt00 - air handling unit - right_daikin_lxwxh 1580x550x1550 mm
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: https://thorbiq.freshdesk.com/support/solutions
